# Keil uVision project 32ctl.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: 32_duoji +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: ..\USER;..\Libraries\src;..\Libraries\inc;..\Startup;..\CMSIS\CM3\CoreSupport;..\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\BSP\servo_gpio;..\USER\servo_control;..\BSP\systick;..\BSP\usart1;..\BSP\tim2;..\USER\analyze_action_group;..\USER\execute_action_group;..\BSP\usart2;..\BSP\tim3;..\USER\modbus_agreement
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ../USER/: stm32f10x_it.c main.c
    ../USER/servo_control/: servo_control.c servo_control.h
    ../USER/analyze_action_group/: analyze_action_group.c analyze_action_group.h
    ../USER/execute_action_group/: execute_action_group.c execute_action_group.h
    ../USER/modbus_agreement/: modbus_agreement.c modbus_agreement.h
  group CMSIS
    ../CMSIS/CM3/CoreSupport/: core_cm3.c
    ../CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group Libraries
    ../Libraries/src/: stm32f10x_gpio.c stm32f10x_rcc.c misc.c stm32f10x_usart.c stm32f10x_i2c.c stm32f10x_tim.c stm32f10x_spi.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_flash.c
  group Startup
    ../Startup/: startup_stm32f10x_hd.s
  group BSP
    ../BSP/servo_gpio/: bsp_servo_gpio.c bsp_servo_gpio.h
    ../BSP/systick/: bsp_systick.c bsp_systick.h
    ../BSP/usart1/: bsp_usart1.c bsp_usart1.h
    ../BSP/tim2/: bsp_tim2.c bsp_tim2.h
    ../BSP/usart2/: bsp_usart2.c bsp_usart2.h
    ../BSP/tim3/: bsp_tim3.c bsp_tim3.h
